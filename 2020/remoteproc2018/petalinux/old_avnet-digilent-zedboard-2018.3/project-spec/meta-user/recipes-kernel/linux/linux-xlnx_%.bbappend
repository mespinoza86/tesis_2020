SRC_URI += "file://bsp.cfg \
            file://user_2020-02-12-23-45-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
