#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " appname"
IMAGE_INSTALL_append = " neuronalinfoli"
IMAGE_INSTALL_append = " jsonfile"
IMAGE_INSTALL_append = " udmabuf"
IMAGE_INSTALL_append = " rtosneurinalinfoli"
IMAGE_INSTALL_append = " rtosneuronalinfoli"
