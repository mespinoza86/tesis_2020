IMAGE_INSTALL_append = " appname"
